<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm32f4xx_htu21d.ewp</path>
    </project>
    <batchBuild />
</workspace>
